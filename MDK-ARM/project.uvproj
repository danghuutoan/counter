# Keil uVision project project.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER USE_FULL_ASSERT HSE_VALUE=8000000 DEVICE_USE_EXTOSC_32KHZ
  c include: ..\libs\fatfs;..\platform\stm32f103\include;..\platform\stm32f103\include\cmsis;..\platform\hal\include;..\platform\common;..\driver\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x8010400 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\obj\project.sct
  group app
    ../app/: main.c
  group driver
    ../driver/: log.c timer.c counter.c rtc.c switch.c led_7segs.c
  group libs
    ../libs/fatfs/: fattime.c ff.c sd_spi_stm32.c
    ../libs/fatfs/option/: ccsbcs.c
  group hal
    ../platform/hal/: hal_com.c hal_dio.c
  group stm32f103
    ../platform/stm32f103/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../platform/stm32f103/startup/arm/: startup_stm32f10x_md.s
